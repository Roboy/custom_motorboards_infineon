# Repository Roboy/custom_motorboards_infineon

## KiCad design Roboy_motorboard/Roboy_motorboard.kicad_pcb

Parts:
C1, C2, C3, C12: 1n; The_0402_FP
C4, C5, C7: 220n; The_0402_FP
C6: 10u; C_0603
C8, C9, C10: 330n; The_0402_FP
C11: 100n; The_0402_FP
JP1: Jumper; Star_Ground_2Port
MK1, MK2, MK3, MK4: M2; MountingHole_2.2mm_M2_DIN965_Pad
NT1: Net-Tie_2; NetTie-2_SMD_Pad0.5mm
R1, R3: 1k; The_0402_FP
R2: 2; The_0402_FP
R4: 10k; The_0402_FP
R24, R25: 100k; The_0402_FP
SW1: SW_Push; SW_SPST_B3U-1000P
TH1: Thermistor_PTC; The_0402_FP
U1: TLE9879QX; QFN-48-1EP_7x7mm_Pitch0.5mm

Connections:
/Driver Bridge Single Mosfet/SH1: C1.1, U1.8 (SH1); also elsewhere on the board
/Driver Bridge Single Mosfet/SH2: C2.1, U1.6 (SH2); also elsewhere on the board
/Driver Bridge Single Mosfet/SH3: C3.1, U1.46 (SH3); also elsewhere on the board
/GH1: U1.9 (GH1); also elsewhere on the board
/GH2: U1.7 (GH2); also elsewhere on the board
/GH3: U1.5 (GH3); also elsewhere on the board
/GL1: U1.13 (GL1); also elsewhere on the board
/GL2: U1.12 (GL2); also elsewhere on the board
/GL3: U1.11 (GL3); also elsewhere on the board
/LIN: U1.43 (LIN); also elsewhere on the board
/OP1: U1.37 (OP1); also elsewhere on the board
/OP2: U1.36 (OP2); also elsewhere on the board
/P0.0: U1.21 (P0.0); also elsewhere on the board
/P0.1: U1.23 (P0.1); also elsewhere on the board
/P0.2: R25.1, U1.25 (P0.2); also elsewhere on the board
/P0.3: U1.24 (P0.3); also elsewhere on the board
/P0.4: U1.18 (P0.4); also elsewhere on the board
/P1.0: U1.15 (P1.0); also elsewhere on the board
/P1.1: U1.16 (P1.1); also elsewhere on the board
/P1.2: U1.17 (P1.2); also elsewhere on the board
/P1.3: U1.26 (P1.3); also elsewhere on the board
/P1.4: U1.27 (P1.4); also elsewhere on the board
/P2.0: U1.29 (P2.0/XTAL1); also elsewhere on the board
/P2.2: U1.30 (P2.2/XTAL2); also elsewhere on the board
/P2.3: R4.2, TH1.2, U1.35 (P2.3)
/P2.4: U1.32 (P2.4); also elsewhere on the board
/P2.5: U1.31 (P2.5); also elsewhere on the board
/RST: C12.1, SW1.1, U1.22 (~RESET); also elsewhere on the board
/SL: U1.10 (SL); also elsewhere on the board
/TMS: R24.1, U1.20 (TMS); also elsewhere on the board
/Vdd_Ext_En: C10.2, U1.41 (VDDEXT); also elsewhere on the board
GNDA: C11.2, NT1.1, TH1.1, U1.33 (GND_REF)
unnamed: C4.1, U1.1 (CP1L)
unnamed: C4.2, U1.48 (CP1H)
unnamed: C5.1, U1.4 (CP2L)
unnamed: C5.2, U1.3 (CP2H)
unnamed: C6.1, R2.1, U1.47 (VSD)
unnamed: C8.2, U1.40 (VDDP)
unnamed: C9.2, U1.38 (VDDC)
unnamed: C11.1, R4.1, U1.34 (VAREF)
unnamed: R1.1, U1.14 (MON)
unnamed: R3.1, U1.44 (VDH)
VCP: C7.1, U1.2 (VCP); also elsewhere on the board
VDH: C7.2, R2.2, R3.2; also elsewhere on the board
VS: R1.2, U1.45 (VS); also elsewhere on the board

Notes on the sheet:
VDH VCP VS GND

Parts:
C13, C14, C15, C16, C18, C19: 4.7n; The_0402_FP
C17: 1n; The_0402_FP
J1: Wago_SMD_3; Wago_2060_3_SMD
Q1, Q2, Q3, Q4, Q5, Q6: CSD18534Q5A; VSON-8_3.3x3.3mm_Pitch0.65mm_NexFET
R5, R6, R9, R10, R16, R17: 2.2; The_0402_FP
R7, R8, R11, R12, R18, R19: 100k; The_0402_FP
R13, R14: 12; The_0402_FP
R15: 5m/3W; R_1206

Connections:
/Driver Bridge Single Mosfet/SH1: C13.2, J1.1, Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.5 (D), R7.2; also elsewhere on the board
/Driver Bridge Single Mosfet/SH2: C15.2, J1.2, Q3.1 (S), Q3.2 (S), Q3.3 (S), Q4.5 (D), R11.2; also elsewhere on the board
/Driver Bridge Single Mosfet/SH3: C18.2, J1.3, Q5.1 (S), Q5.2 (S), Q5.3 (S), Q6.5 (D), R18.2; also elsewhere on the board
/GH1: R5.2; also elsewhere on the board
/GH2: R9.2; also elsewhere on the board
/GH3: R16.2; also elsewhere on the board
/GL1: R6.2; also elsewhere on the board
/GL2: R10.2; also elsewhere on the board
/GL3: R17.2; also elsewhere on the board
/OP1: C17.2, R14.2; also elsewhere on the board
/OP2: C17.1, R13.2; also elsewhere on the board
/SL: C14.2, C16.2, C19.2, Q2.1 (S), Q2.2 (S), Q2.3 (S), Q4.1 (S), Q4.2 (S), Q4.3 (S), Q6.1 (S), Q6.2 (S), Q6.3 (S), R8.2, R12.2, R13.1, R15.1, R19.2; also elsewhere on the board
unnamed: C13.1, Q1.4 (G), R5.1, R7.1
unnamed: C14.1, Q2.4 (G), R6.1, R8.1
unnamed: C15.1, Q3.4 (G), R9.1, R11.1
unnamed: C16.1, Q4.4 (G), R10.1, R12.1
unnamed: C18.1, Q5.4 (G), R16.1, R18.1
unnamed: C19.1, Q6.4 (G), R17.1, R19.1
VDH: Q1.5 (D), Q3.5 (D), Q5.5 (D); also elsewhere on the board

Parts:
C34, C37, C38, C39, C43, C44, C45, C46, C47, C48, C49: 100n; The_0402_FP
C35, C36: 1u; The_0402_FP
C40: 4.7u; The_0402_FP
C41: 10u; The_0402_FP
C42: 10n; The_0402_FP
D4: Neo-Pixel; LED_WS2812B-PLCC4_3.5x3.5
D5: 5V_Ok_Green; LED_0603_1608Metric
D7, D8, D9: PMEG4010AESBYL; D_SOD-993
J2: Motor_Encoder; TE-Connectivity_Micro-Match_connector_02x03_Pitch_1.27mm
J3: Hall_Sensors; TE-Connectivity_Micro-Match_connector_02x03_Pitch_1.27mm
J4: LIN_PIN1; Measurement_Point_Round-SMD-Pad_Small
J6: SPI2; TE-Connectivity_Micro-Match_connector_02x03_Pitch_1.27mm
J7: SPI1 / I2C / Disp; TE-Connectivity_Micro-Match_connector_02x03_Pitch_1.27mm
J8: Simic_D; TestPoint_Pad_D1.5mm
J9: Simic_C; TestPoint_Pad_D1.5mm
L2: 2.2u; L_0805_2012Metric
R22, R23, R32, R44, R45, R46, R47: 10k; The_0402_FP
R26, R29, R36, R37, R38, R39, R40, R41, R42, R43: 1k; The_0402_FP
R30, R33, R48, R49: 100k; The_0402_FP
R31: 5.6k; The_0402_FP
SW2: SW_DIP_x02; SW_DIP_x2_W5.08mm_Slide_Copal_CHS-A
U2: LM2903
U3, U4: FSA2259; UQFN-10_1.4x1.8mm_Pitch0.4mm
U5: BMI160; Bosch_LGA-14_3x2.5mm_P0.5mm
U6: NTS0102; X2SON-8_1.4x1mm_P0.35mm
U7: MIC5317-3.3YMT-TZ; 4-DFN
U8: Simic_Infineon; IM69D130_Simic_uPhone
U9: AOZ1280; SOT-23-6

Connections:
/Comms/3V3: C34.1, C36.1, C37.1, C38.2, R32.2, U5.1 (SDO), U5.5 (VDDIO), U5.8 (VDD), U5.12 (CSB), U6.3 (VCCA), U7.1 (VOUT), U8.2 (VDD)
/Comms/A+: J2.4, R36.2
/Comms/A-: J2.3, R37.2
/Comms/B+: J2.6, R38.2
/Comms/B-: J2.5, R39.2
/Comms/LED: D4.3 (GK), U4.5 (1B0)
/Comms/MISO1/DispA-TMS: J7.4, U3.3 (1A)
/Comms/MOSI1/SDA/DispB-RST: J7.5, U3.9 (2A)
/Comms/SS1/DispAo/SWCLK: J7.3, U4.9 (2A)
/LIN: J4.1; also elsewhere on the board
/P0.0: U4.3 (1A); also elsewhere on the board
/P0.1: U3.5 (1B0); also elsewhere on the board
/P0.2: U3.7 (2B0), U6.8 (B1); also elsewhere on the board
/P0.3: J7.6, U6.1 (B2); also elsewhere on the board
/P0.4: J3.4; also elsewhere on the board
/P1.0: J6.6; also elsewhere on the board
/P1.1: J6.5; also elsewhere on the board
/P1.2: J6.4; also elsewhere on the board
/P1.3: J3.3; also elsewhere on the board
/P1.4: J6.3; also elsewhere on the board
/P2.0: R46.1, R48.1, U2.1; also elsewhere on the board
/P2.2: J3.5; also elsewhere on the board
/P2.4: R47.1, R49.2, U2.7; also elsewhere on the board
/P2.5: U4.7 (2B0); also elsewhere on the board
/RST: U3.10 (2B1); also elsewhere on the board
/TMS: U3.2 (1B1); also elsewhere on the board
/Vdd_Ext: C35.1, C39.2, C43.2, C44.1, C45.1, D4.4 (BK), D8.1 (K), D9.1 (K), J2.1, J3.1, J6.1, J7.1, R26.2, R48.2, R49.1, SW2.1, SW2.2, U2.8 (V+), U3.1 (VCC), U4.1 (VCC), U6.7 (VCCB), U7.3 (EN), U7.4 (VIN)
/Vdd_Ext_En: D8.2 (A), R33.2; also elsewhere on the board
unnamed: C41.2, D9.2 (A), L2.2, R31.2
unnamed: C42.1, U9.1 (BST)
unnamed: C42.2, D7.1 (K), L2.1, U9.6 (LX)
unnamed: C46.1, R36.1, R40.2
unnamed: C47.2, R37.1, R41.2
unnamed: C48.1, R38.1, R42.2
unnamed: C49.2, R39.1, R43.2
unnamed: D5.2 (A), R26.1
unnamed: J8.1, U8.1 (DATA)
unnamed: J9.1, U8.3 (CLK)
unnamed: R22.2, SW2.4, U3.4 (S1), U3.8 (S2)
unnamed: R23.2, SW2.3, U4.4 (S1), U4.8 (S2)
unnamed: R29.1, R31.1, U9.3 (FB)
unnamed: R30.1, R33.1, U9.4 (EN)
unnamed: R32.1, U6.6 (OE)
unnamed: R40.1, R44.1, R46.2, U2.3 (+)
unnamed: R41.1, R44.2, U2.2 (-)
unnamed: R42.1, R45.1, R47.2, U2.5 (+)
unnamed: R43.1, R45.2, U2.6 (_)
unnamed: U4.2 (1B1), U4.10 (2B1)
unnamed: U5.13 (SCx), U6.4 (A2)
unnamed: U5.14 (SDx), U6.5 (A1)
VDH: C40.2, R30.2, U9.5 (VIN); also elsewhere on the board

Notes on the sheet:
Optional input filter
Enable Vdd_Ext supply from the TLE chip
Place if switching converter is present
R33 enables the chip with the Vdd_ext signal from the uController. R30 enables the chip permanently with VDH = ON Place one or the other
Optional for impedance matching

Parts:
C20, C22, C24: 100n/50V; The_0402_FP
C21, C25, C26, C27, C28, C29, C30, C31, C32: 22u/50V; C_0805
C23: 22u/50V; CP_Elec_4x4.5
C33: 220u; CP_Elec_6.3x4.5
D1: D_TVS; D_0603
D2, D3: PMEG4010AESBYL; D_SOD-993
D6: LED_Dual_AACC; LED_Dual_0603_AACC
F1: Fuse_Small; Fuse_1206_3216Metric
J10: Wago_SMD_2; Wago_2060_2_SMD
L1: 4.7u; L_7.3x7.3_H4.5
Q7: CSD18534Q5A; VSON-8_3.3x3.3mm_Pitch0.65mm_NexFET
Q8: Q_NPN_BCE; SOT-23
R20: 3.3k; The_0402_FP
R21, R27, R28, R34, R35: 10k; The_0402_FP

Connections:
/Power in/VIN: C20.1, C21.1, D1.1 (A1), F1.1, J10.1, R27.1, R34.1
unnamed: C22.2, Q8.1 (B), R21.2
unnamed: D2.1 (K), L1.2, Q7.1 (S), Q7.2 (S), Q7.3 (S)
unnamed: D2.2 (A), Q8.3 (E)
unnamed: D6.1 (A1), R27.2, R34.2
unnamed: D6.2 (A2), R28.2, R35.2
unnamed: F1.2, L1.1
unnamed: Q7.4 (G), Q8.2 (C), R20.2
VCP: C22.1, R20.1; also elsewhere on the board
VDH: C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, D3.2 (A), D6.3 (K1), Q7.5 (D), R28.1, R35.1; also elsewhere on the board
VS: C23.1, C24.1, D3.1 (K); also elsewhere on the board

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
Board: 4 copper layers, 46.0 x 34.8 mm, 146 parts (103 on the bottom side), 93 nets.

Other parts of the board:
svg2mod: G***; Roboy_Logo_F.Cu

## Commit log

2017-09-20 Initial commit. Finished first schematic for the motorboard and modeled some connectors. Capacitor values and some footprints still undecided.
2017-09-23 Corrected some mistakes, deleted superfluous connectors and constrained redundancies.
2018-01-18 Super commit after a long time. Finished routing power layers, and began routing the signal layers. Added analog switching mechanism to cope for the lack of pins and drive the Neopixel/I2C/SPI. Intro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
2018-06-15 V1 Manufacturing commit: Included some fixes both in the schematic and layout, finished routing (finally\!) and updated some footprints (Microphone). Also added a linear regulator to help supply the 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
2018-08-07 Some files exported to pdf for documentation. Small batch of fixes to the schematics, mainly I2C to the IMU and some naming, nothing on the layout yet. And OH GOD WHY, changed the pin assignments. Wh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
2018-08-15 Updated pin assignment (yet again) for the hall sensors, and almost finished the new routing modifications.
2018-08-27 Small batch of fixes in the schematics. Added the preliminary version of the new switching 5V regulator.
2018-08-27 OH GOD REVERT, REVERT!!!! I'm an idiot, I checked out an old version to compare the layout and forgot to turn back to the most recent; so I commited this old version. Revert "Small batch of fixes in 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
    This reverts commit 76c40a9226b348a7109a12c3399958bf17007883.
2019-01-22 Upgraded files and finished revision B of the board. All networks are fixed, new switching DC/DC converter for the 5V rail, replaced encoder rs485 chip since it was an old TTL one which drew 35mA in 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
2019-02-11 Implemented the fix on C9 from the Infineon experts by disconnecting Pin 39 from GND and connecting to GNDD directly to the cap; now boards work stable \! Also fixed some extraneous pads appearing an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
2019-02-12 Changed the signal conditioning circuitry for the encoder inputs (yet again ... -.-). Now we fully use the differential signaling and have optional input filters (since the comparators sit directly o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
2019-02-13 Some cosmetic changes in the layout. Quick save before implementing changes on the PCB.
2019-02-13 Holy macaroni, managed to implement all schematic changes on the layout\! Puh... Modified the LED arrangement in PWR_In, cleaned silkscreen up, oh and changed the input fuse to 1206 since there was s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
2019-02-13 Panelized boards in an array of 3 in order to stay below 100x100mm to save costs at PCBWay. Although the effect is kind of small, since now they always check if you somehow are sneaking multiple PCBs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
2019-02-20 Updated BOM file for revB with Top and Bottom layer placement sorting
